SRC_URI = "git://github.com/PLi-metas/uchardet.git"
