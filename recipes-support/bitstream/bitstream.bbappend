SRC_URI = "git://github.com/PLi-metas/bitstream.git"
