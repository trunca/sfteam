PV = "git${SRCPV}"
SRC_URI = "git://github.com/PLi-metas/oscam.git;protocol=git;name=trunk"
S = "${WORKDIR}/git"
SRCREV_pn-enigma2-plugin-softcams-oscam = "${AUTOREV}"
