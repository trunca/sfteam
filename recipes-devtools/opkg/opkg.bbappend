FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://revert-part-of-commit-7a8c2f6.patch \
	"
