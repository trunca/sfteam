SRC_URI = "git://github.com/PLi-metas/iptvplayer-bin-components.git"
