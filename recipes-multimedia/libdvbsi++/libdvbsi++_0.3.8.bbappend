SRC_URI = "git://github.com/PLi-metas/libdvbsi.git"
