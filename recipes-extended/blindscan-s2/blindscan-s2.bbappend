SRC_URI = "git://github.com/PLi-metas/blindscan-s2.git"
